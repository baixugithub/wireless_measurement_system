# Keil uVision project Demo.uvproj, settings and files
target Slave1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Demo +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS\CoreSupport;..\..\CMSIS\STM32F10x;..\..\Hardware\inc;..\..\Libraries\inc;..\..\user\inc;..\..\system\inc;..\..\TEXT;..\..\FATFS\src;..\..\FATFS\exfuns
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../../user/src/: main.c stm32f10x_it.c
  group Hardware
    ../../Hardware/src/: led.c lcd.c key.c flash.c spi.c 24l01.c mmc_sd.c 24cxx.c myiic.c ds18b20.c
  group system
    ../../system/src/: delay.c system.c usart.c
  group Libraries
    ../../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group startup
    ../../startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../CMSIS/CoreSupport/: core_cm3.c
    ../../CMSIS/STM32F10x/: system_stm32f10x.c
  group FATFS
    ../../FATFS/exfuns/: exfuns.c mycc936.c
    ../../FATFS/src/: diskio.c ff.c
  group TEXT
    ../../TEXT/: fontupd.c text.c
  group Description
    ../../Description/: Description.txt
